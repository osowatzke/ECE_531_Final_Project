options:
  parameters:
    generate_options: hb_qt_gui
    id: cfo_hier
    output_language: python
    title: CFO
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    value: '8192'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,0,1,1
    name: CFO Frequency Estimate
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: ''
    num_tabs: '1'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    gui_hint: 1,0,10,1
    vlen: fft_size
    x_axis_label: Frequency (Hz)
    x_start: '-0.5*samp_rate'
    x_step: samp_rate/fft_size
    y_axis_label: Magnitude (dB)
    ymin: '-80'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: 3.28e6
  states: {}
- name: xm_module_qpsk_fft_cfo_est_0
  id: xm_module_qpsk_fft_cfo_est
  parameters:
    fft_size: '8192'
    samp_rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '0', xm_module_qpsk_fft_cfo_est_0, '0']
- [xm_module_qpsk_fft_cfo_est_0, '0', qtgui_number_sink_0, '0']
- [xm_module_qpsk_fft_cfo_est_0, '1', qtgui_vector_sink_f_1, '0']
- [xm_module_qpsk_fft_cfo_est_0, freq_msg, analog_sig_source_x_0, cmd]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
