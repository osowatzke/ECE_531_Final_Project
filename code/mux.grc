options:
  parameters:
    generate_options: hb
    id: mux
    output_language: python
    title: Mux
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: in0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: in1
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: sel_0
  id: blocks_multiply_const_vxx
  parameters:
    const: not select
    type: complex
  states: {}
- name: sel_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: select
    type: complex
  states: {}
- name: select
  id: parameter
  parameters:
    type: complex
    value: 'False'
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [in0, '0', sel_0, '0']
- [in1, '0', sel_0_0, '0']
- [sel_0, '0', blocks_add_xx_0, '0']
- [sel_0_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
