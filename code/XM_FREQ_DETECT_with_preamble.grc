options:
  parameters:
    generate_options: qt_gui
    id: XM_FREQ_DETECT
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FSP
  id: variable
  parameters:
    value: '[-1,  1, -1,  1, -1, -1,  1,  1, -1,  1,  1,  1, -1, -1, -1, -1,  1, -1,  1, -1, -1,  1,  1, -1,  1,  1,  1, -1, -1, -1, -1,  1]'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.64e6*2
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: XM_test_x2_sync.dat
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: xm_data_bits.dat
    type: complex
    vlen: '3456'
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: xm_data_bits2.dat
    type: float
    vlen: '5440'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../data/XM_test_x2.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '5440'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '3456'
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: FSP[::-1]
    type: ccf
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.15'
    decim: '1'
    gain: '1'
    ntaps: '21'
    samp_rate: samp_rate
    sym_rate: samp_rate/2
    type: ccc
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: '2'
    taps: '1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@4
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@3
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    label1: Input Signal
    label2: RRC Filter Output
    nconnections: '2'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'qtgui_tab_widget_0@0: 0,0,1,1'
    name: CFO Frequency Estimate
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: CFO FFT Output
    label1: Spectrum
    label2: Const. before Timing Comp
    label3: Const. after Timing Comp
    label4: Const. after Phase Comp
    label5: Correlation with FSP
    num_tabs: '6'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab_widget_0@5
    nconnections: '2'
    vlen: '3456'
    x_start: '0'
    x_step: '1.0'
    ymax: '40'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab_widget_0@5
    nconnections: '2'
    vlen: '3456'
    x_start: '0'
    x_step: '1.0'
    ymax: '40'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    gui_hint: 'qtgui_tab_widget_0@0: 1,0,10,1'
    vlen: fft_size
    x_axis_label: Frequency (Hz)
    x_start: '-0.5*samp_rate'
    x_step: samp_rate/fft_size
    y_axis_label: Magnitude (dB)
    ymax: '-60'
    ymin: '-120'
  states: {}
- name: qtgui_vector_sink_f_2
  id: qtgui_vector_sink_f
  parameters:
    vlen: '3456'
    x_start: '0'
    x_step: '1.0'
    ymax: '72'
    ymin: '0'
  states: {}
- name: xm_module_extract_data_bits_0
  id: xm_module_extract_data_bits
  parameters: {}
  states: {}
- name: xm_module_mfp_align_0
  id: xm_module_mfp_align
  parameters: {}
  states: {}
- name: xm_module_preamble_detector_0
  id: xm_module_preamble_detector
  parameters:
    fsp: FSP
  states: {}
- name: xm_module_qpsk_fft_cfo_est_0
  id: xm_module_qpsk_fft_cfo_est
  parameters:
    fft_size: '8192'
    samp_rate: samp_rate
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', pfb_decimator_ccf_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', xm_module_qpsk_fft_cfo_est_0, '0']
- [blocks_multiply_xx_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_0, '0']
- [digital_costas_loop_cc_0, '0', fft_filter_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', xm_module_preamble_detector_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [filter_fft_rrc_filter_0, '0', analog_agc_xx_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [pfb_decimator_ccf_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [xm_module_extract_data_bits_0, '0', blocks_file_sink_1_0, '0']
- [xm_module_extract_data_bits_0, '0', blocks_null_sink_0, '0']
- [xm_module_mfp_align_0, '0', blocks_file_sink_1, '0']
- [xm_module_mfp_align_0, '0', xm_module_extract_data_bits_0, '0']
- [xm_module_mfp_align_0, '1', qtgui_vector_sink_f_2, '0']
- [xm_module_mfp_align_0, frame_count, blocks_message_debug_0, log]
- [xm_module_preamble_detector_0, '0', xm_module_mfp_align_0, '0']
- [xm_module_preamble_detector_0, '1', qtgui_vector_sink_f_0_0, '0']
- [xm_module_preamble_detector_0, '2', qtgui_vector_sink_f_0_0, '1']
- [xm_module_qpsk_fft_cfo_est_0, '0', qtgui_number_sink_0, '0']
- [xm_module_qpsk_fft_cfo_est_0, '1', qtgui_vector_sink_f_1, '0']
- [xm_module_qpsk_fft_cfo_est_0, freq_msg, analog_sig_source_x_0, cmd]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
