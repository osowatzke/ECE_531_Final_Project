options:
  parameters:
    generate_options: qt_gui
    id: xm_radio_collect
    output_language: python
    title: XM Radio Collected
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: bandwidth
    start: 100E3
    step: 1E3
    stop: 25E6
    value: 1.886E6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 70E6
    step: 1e6
    stop: 6E9
    value: 2335.305E6
  states: {}
- name: rx_manual_gain
  id: variable_qtgui_range
  parameters:
    label: RX Manual Gain
    start: '0'
    step: '1'
    stop: '71'
    value: '60'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: 1e6
    step: 1e3
    stop: 50e6
    value: 3.28E6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../data/XM_test_x2.dat
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bandwidth
    bbdc: 'True'
    buffer_size: 2**20
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: rx_manual_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 2**15
    type: complex
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.2.1
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
