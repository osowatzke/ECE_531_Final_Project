options:
  parameters:
    generate_options: qt_gui
    id: XM_FREQ_DETECT
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.64e6*2
  states: {}
- name: agc_sink
  id: virtual_sink
  parameters:
    stream_id: AGC Out
  states: {}
- name: agc_source
  id: virtual_source
  parameters:
    stream_id: AGC Out
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: XM_test_x2_sync.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../data/XM_test_x2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cfc_sink
  id: virtual_sink
  parameters:
    stream_id: CFC Out
  states: {}
- name: cfc_source
  id: virtual_source
  parameters:
    stream_id: CFC Out
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.15'
    decim: '1'
    gain: '1'
    ntaps: '21'
    samp_rate: samp_rate
    sym_rate: samp_rate/2
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@4
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@3
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0
    label1: Before RRC Filter
    label2: After RRC Filter
    nconnections: '2'
    type: complex
    ymax: '-20'
    ymin: '-160'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'qtgui_tab_widget_0@1: 0,0,1,1'
    name: CFO Frequency Estimate
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: CFO FFT Output
    label2: Input Constellation
    label3: Const. after Timing Comp
    label4: Const. after Phase Comp
    label5: FSP Correlation
    num_tabs: '6'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '3456'
    x_start: '0'
    x_step: '1.0'
    ymax: '40'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    average: '0.1'
    gui_hint: 'qtgui_tab_widget_0@1: 1,0,10,1'
    vlen: fft_size
    x_axis_label: Frequency (Hz)
    x_start: '-0.5*samp_rate'
    x_step: samp_rate/fft_size
    y_axis_label: Magnitude (dB)
    ymin: '-80'
  states: {}
- name: xm_module_preamble_detector_0
  id: xm_module_preamble_detector
  parameters:
    fsp: '[-1,  1, -1,  1, -1, -1,  1,  1, -1,  1,  1,  1, -1, -1, -1, -1, 1, -1,  1, -1, -1,  1,  1, -1,  1,  1,  1, -1, -1, -1, -1,  1]'
  states: {}
- name: xm_module_qpsk_fft_cfo_est_0
  id: xm_module_qpsk_fft_cfo_est
  parameters:
    fft_size: '8192'
    samp_rate: samp_rate
  states: {}

connections:
- [agc_source, '0', blocks_multiply_xx_0, '1']
- [analog_agc_xx_0, '0', agc_sink, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [analog_agc_xx_0, '0', xm_module_qpsk_fft_cfo_est_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', cfc_sink, '0']
- [blocks_throttle2_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [cfc_source, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', xm_module_preamble_detector_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [filter_fft_rrc_filter_0, '0', analog_agc_xx_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [xm_module_preamble_detector_0, '0', qtgui_vector_sink_f_0, '0']
- [xm_module_qpsk_fft_cfo_est_0, '0', qtgui_number_sink_0, '0']
- [xm_module_qpsk_fft_cfo_est_0, '1', qtgui_vector_sink_f_1, '0']
- [xm_module_qpsk_fft_cfo_est_0, freq_msg, analog_sig_source_x_0, cmd]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
