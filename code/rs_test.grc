options:
  parameters:
    generate_options: qt_gui
    id: rs_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1+1j, -1-1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100e3 #(2040*258)/0.432'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: ../data/data_mod.dat
    length: 255*8*2
    maxoutbuf: '1024'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: 255*1
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 223*1
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '1'
    gfpoly: '285'
    k: '223'
    m: '8'
    n: '255'
    p: '2'
    s: '0'
    t: '16'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Decoded Data
    size: 223*2
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '-256'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Received Data
    size: 255*2
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '-256'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Received Symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Received Symbols
  states: {}

connections:
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_1, '0', blocks_throttle2_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_char_to_float_1_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_1, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [blocks_throttle2_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_char_to_float_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
